# Keil uVision project 1.uvproj, settings and files
target Target1 (MCS-51)
  device: OB38S003 On-Bright
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM(0-0xFF) CLOCK(16000000)
  output: 1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\1;.\HARDWARE;.\HARDWARE\AD;.\HARDWARE\Disp;.\HARDWARE\ErrTest;.\HARDWARE\FlaCon;.\HARDWARE\HeatCon;.\HARDWARE\iic;.\HARDWARE\Initial;.\HARDWARE\IR;.\HARDWARE\Key;.\HARDWARE\main;.\HARDWARE\SH_EEPROM;.\HARDWARE\SysTimer;.\HARDWARE\tm1638;.\HARDWARE\Uart;.\HARDWARE\LedAutoCon;.\HARDWARE\SysInit
  group Source Group 1
    ./: main.c STARTUP.A51
    ./HARDWARE/: AD.c WDT.c
  group IR
    ./HARDWARE/IR/: Ir.c
  group KEY
    ./HARDWARE/KEY/: FlaKey.c GainAdKeyValue.c PowerKey.c SysKey.c TempKye.c TimerKey.c DowKey.c
  group Disp
    ./HARDWARE/Disp/: Disp.c
  group AD
    ./HARDWARE/ADC/: ADC.c
  group SysTimer
    ./HARDWARE/SysTimer/: SysTimer.c
  group HeatCon
    ./HARDWARE/HeatCon/: HeatCon.c
  group ErrTest
    ./HARDWARE/ErrTest/: ErrTest.c
  group Tm1616
    ./HARDWARE/TM1638/: TM1638.C
  group SysInit
    ./HARDWARE/SysInit/: SysInit.c
  group LedAutoCon
    ./HARDWARE/LedAutoCon/: LedAutoCon.c
