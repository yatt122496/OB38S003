# Keil uVision project 1.uvproj, settings and files
target Target1 (MCS-51)
  device: CMS8S7895 Cmsemicon
  cpu: IRAM(0 - 0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) CLOCK(24000000) MODDP2
  output: 1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..;.\HARDWARE;.\HARDWARE\Lib\inc
  group main
    ./: main.c
    ./HARDWARE/: STARTUP_CMS8S7895.A51
  group Lib
    ./HARDWARE/Lib/src/: adc.c flash.c gpio.c system.c timer.c wdt.c epwm.c extint.c
  group SysInit
    ./HARDWARE/Initial/: Initial.c
  group FlaCon
    ./HARDWARE/FlaCon/: FalCon.c
  group HeatCon
    ./HARDWARE/HeatCon/: HeatCon.C
  group NtcAd
    ./HARDWARE/AD/: ad.c
  group VrAd
    ./HARDWARE/VrAd/: VrAd.c
  group Key
    ./HARDWARE/key/: FlaKey.c GainAdKeyValue.c HaetKey.c PowerKey.c SysKey.c
  group Ir
    ./HARDWARE/IR/: Ir.c
  group SysTimer
    ./HARDWARE/SysTimer/: SysTimer.c
  group SH_EEPROM
    ./HARDWARE/SH_EEPROM/: SH_EEPROM.c SysMem.c
  group EUART
    ./HARDWARE/Euart/: MP3_680_681 .c
