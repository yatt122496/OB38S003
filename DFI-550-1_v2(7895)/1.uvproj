# Keil uVision project 1.uvproj, settings and files
target Target1 (MCS-51)
  device: CMS8S7895 Cmsemicon
  cpu: IRAM(0 - 0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) CLOCK(24000000) MODDP2
  output: 1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..;.\HARDWARE;.\HARDWARE\Lib\inc
  link misc: REMOVEUNUSED
  group main
    ./: main.c
    ./HARDWARE/: STARTUP_CMS8S7895.A51
  group mcu
    ./HARDWARE/Mcu/: Euart.c Int0.c Int1.c Int2.c Interrupt.c McuInit.c PWM.c SH_EEPROM.c SysClkInit.c Timer0.c Timer1.c Timer2.c Timer3.c Timer4.c
  group KEY
    ./HARDWARE/Key/: FlaKey.c HeatKey.c PowerKey.c SysKey.c
  group FlaCon
    ./HARDWARE/FlaCon/: FlaCon.c
  group HeatCon
    ./HARDWARE/HeatCon/: HeatCon.c
  group Disp
    ./HARDWARE/Disp/: Disp.c
  group SysMem
    ./HARDWARE/SysMem/: SysMem.c
  group ir
    ./HARDWARE/IR/: Ir.c
  group AD
    ./HARDWARE/AD/: ad.c
    ./HARDWARE/VrAd/: VrAd.c
  group ErrCon
    ./HARDWARE/ErrTest/: ErrTest.c
  group Lib
    ./HARDWARE/Lib/src/: adc.c epwm.c extint.c flash.c gpio.c system.c timer.c wdt.c
