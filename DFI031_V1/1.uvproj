# Keil uVision project 1.uvproj, settings and files
target Target1 (MCS-51)
  device: OB38S003 On-Bright
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM(0-0xFF) CLOCK(16000000)
  output: 1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\HARDWARE\AD;.\HARDWARE\Euart;.\HARDWARE\FlaCon;.\HARDWARE\HeatCon;.\HARDWARE\Initial;.\HARDWARE\IR;.\HARDWARE\key;.\HARDWARE\main;.\HARDWARE\SH_EEPROM;.\HARDWARE\SysTimer;.\HARDWARE\VrAd;.\HARDWARE;..\DFI031_V1
  group main
    ./: main.c STARTUP.A51
    ./HARDWARE/: ADC.c EEPROM.c UART0.c WDT.c
  group SysInit
    ./HARDWARE/Initial/: Initial.c
  group FlaCon
    ./HARDWARE/FlaCon/: FalCon.c
  group HeatCon
    ./HARDWARE/HeatCon/: HeatCon.C
  group NtcAd
    ./HARDWARE/AD/: ad.c
  group VrAd
    ./HARDWARE/VrAd/: VrAd.c
  group Key
    ./HARDWARE/key/: FlaKey.c GainAdKeyValue.c HaetKey.c PowerKey.c SysKey.c
  group Ir
    ./HARDWARE/IR/: Ir.c
  group SysTimer
    ./HARDWARE/SysTimer/: SysTimer.c
  group SH_EEPROM
    ./HARDWARE/SH_EEPROM/: SH_EEPROM.c SysMem.c
