# Keil uVision project 1.uvproj, settings and files
target Target1 (MCS-51)
  device: OB38S003 On-Bright
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM(0-0xFF) CLOCK(16000000)
  output: 1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\HARDWARE\HeatCon;.\HARDWARE\IR;.\HARDWARE\key;.\HARDWARE\main;.\HARDWARE\SysTimer;.\HARDWARE;.\HARDWARE\ADC;.\HARDWARE\Disp;.\HARDWARE\ErrTest;.\HARDWARE\SysInit;.\HARDWARE\TM1638
  group main
    ./: main.c STARTUP.A51
    ./HARDWARE/: AD.c UART0.c WDT.c
  group Key
    ./HARDWARE/KEY/: FlaKey.c GainAdKeyValue.c PowerKey.c SysKey.c TempKye.c TimerKey.c
  group IR
    ./HARDWARE/IR/: Ir.c
  group SysTimer
    ./HARDWARE/SysTimer/: SysTimer.c
  group Disp
    ./HARDWARE/Disp/: Disp.c
  group Tm1616
    ./HARDWARE/TM1638/: TM1638.C
  group SysInit
    ./HARDWARE/SysInit/: SysInit.c
  group ADC
    ./HARDWARE/ADC/: ADC.c
  group HeatCon
    ./HARDWARE/HeatCon/: HeatCon.c
  group LedAutoCon
    ./HARDWARE/LedAutoCon/: LedAutoCon.c
  group ErrTest
    ./HARDWARE/ErrTest/: ErrTest.c
