# Keil uVision project 1.uvproj, settings and files
target Target1 (MCS-51)
  device: CMS8S7895 Cmsemicon
  cpu: IRAM(0 - 0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) CLOCK(24000000) MODDP2
  output: 1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..;.\HARDWARE;.\HARDWARE\Lib\inc
  link misc: REMOVEUNUSED
  group main
    ./: main.c
    ./HARDWARE/: STARTUP_CMS8S7895.A51
  group Lib
    ./HARDWARE/Lib/src/: adc.c flash.c gpio.c system.c timer.c wdt.c epwm.c extint.c
  group Key
    ./HARDWARE/KEY/: DowKey.c FlaKey.c GainAdKeyValue.c PowerKey.c SysKey.c TempKye.c TimerKey.c UpKey.c
  group IR
    ./HARDWARE/IR/: Ir.c
  group SysTimer
    ./HARDWARE/SysTimer/: SysTimer.c
  group Disp
    ./HARDWARE/Disp/: Disp.c
  group Tm1616
    ./HARDWARE/TM1638/: TM1638.C
  group SysInit
    ./HARDWARE/SysInit/: SysInit.c
  group ADC
    ./HARDWARE/ADC/: ad.c
  group HeatCon
    ./HARDWARE/HeatCon/: HeatCon.c
  group LedAutoCon
    ./HARDWARE/LedAutoCon/: LedAutoCon.c
  group ErrTest
    ./HARDWARE/ErrTest/: ErrTest.c
