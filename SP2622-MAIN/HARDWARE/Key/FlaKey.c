/***********************************************************
*  文件说明：摇控程序                                             
************************************************************
*  日期:2011.12.22 19:55 
*									                                                                                                                                            
*  作者:  cuoiszf                                                                                           
*                                                          
************************************************************
*  硬件：sh79f083                                                
************************************************************
* 【版权】 Copyright(C)鹏林电子                           
* 【声明】                                
***********************************************************/
#include "HARDWARE\main\SysInc.h"
//----------------------------------------------------------
uint8  FlaGears;
/************************************************************
* 
* 		   火焰显示
************************************************************/
void FlaDisp( void )
{  
  if(FlaGears){
    DispDct3   = FlaGears;
  }else{
	DispDct1 =  0 ;
	DispDct2 = _F_;
    DispDct3 = _F_;  
  }
  LedFla = 1;  
}
/************************************************************
* 
* 			火焰键
************************************************************/
void FlaKey( void )
{
   CancelAllFlash(1);
   if(!Standby){ 
     Standby = 1;  
     KeyAct  = 0;
   }
  //----------------
	if(PowerOn){
	 PowerOn = 0;
	 FlaGears=5; //按下FLA KEY 火焰为5档
    }
  //----------------   
   DispDataSet = &FlaDisp; 
   if(KeyAct & K2_FLA || (!FlaGears)){     
     if(++FlaGears > 5){     
       FlaGears=0;
     }
   }
   //----------------          
   KeyAct=K2_FLA;       
}
