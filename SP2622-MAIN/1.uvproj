# Keil uVision project 1.uvproj, settings and files
target Target1 (MCS-51)
  device: OB38S003 On-Bright
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM(0-0xFF) CLOCK(16000000)
  output: 1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\1;.\HARDWARE;.\HARDWARE\AD;.\HARDWARE\Disp;.\HARDWARE\ErrTest;.\HARDWARE\FlaCon;.\HARDWARE\HeatCon;.\HARDWARE\iic;.\HARDWARE\Initial;.\HARDWARE\IR;.\HARDWARE\Key;.\HARDWARE\main;.\HARDWARE\SH_EEPROM;.\HARDWARE\SysTimer;.\HARDWARE\tm1638;.\HARDWARE\Uart
  group Source Group 1
    ./: main.c STARTUP.A51
    ./HARDWARE/: ADC.c PWM.c WDT.c UART0.c
  group McuInit
    ./HARDWARE/Initial/: Initial.c
  group IR
    ./HARDWARE/IR/: Ir.c
  group KEY
    ./HARDWARE/Key/: DwlKey.c FlaKey.c HeatKey.c PowerKey.c SysKey.c TempProcKye.c TimerKey.c
  group IIC
    ./HARDWARE/iic/: iic.c
  group Disp
    ./HARDWARE/Disp/: Disp.c
  group AD
    ./HARDWARE/AD/: ad.c
  group SysTimer
    ./HARDWARE/SysTimer/: SysTimer.c
  group FlaCon
    ./HARDWARE/FlaCon/: FalCon.c
  group HeatCon
    ./HARDWARE/HeatCon/: HeatCon.c
  group ErrTest
    ./HARDWARE/ErrTest/: ErrTest.c
  group E33机型配置
    ./HARDWARE/main/: EF_II033_Inc.h
