# Keil uVision project 1.uvproj, settings and files
target Target1 (MCS-51)
  device: CMS8S7895 Cmsemicon
  cpu: IRAM(0 - 0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) CLOCK(24000000) MODDP2
  output: 1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..;.\HARDWARE;.\HARDWARE\Lib\inc
  link misc: REMOVEUNUSED
  group main
    ./: main.c
    ./HARDWARE/: STARTUP_CMS8S7895.A51
  group Lib
    ./HARDWARE/Lib/src/: adc.c flash.c gpio.c system.c timer.c wdt.c epwm.c extint.c
  group McuInit
    ./HARDWARE/Initial/: Initial.c
  group IR
    ./HARDWARE/IR/: Ir.c
  group KEY
    ./HARDWARE/Key/: DwlKey.c FlaKey.c GainAdKeyValue.c HeatKey.c PowerKey.c SysKey.c TempProcKye.c TimerKey.c
  group Disp
    ./HARDWARE/Disp/: Disp.c
  group AD
    ./HARDWARE/AD/: ad.c
  group SysTimer
    ./HARDWARE/SysTimer/: SysTimer.c
  group TM1616
    ./HARDWARE/TM1638/: TM1638.C
  group FlaCon
    ./HARDWARE/FlaCon/: FalCon.c
  group HeatCon
    ./HARDWARE/HeatCon/: HeatCon.c
  group ErrTest
    ./HARDWARE/ErrTest/: ErrTest.c
  group E33机型配置
    ./HARDWARE/main/: EF_II033_Inc.h
